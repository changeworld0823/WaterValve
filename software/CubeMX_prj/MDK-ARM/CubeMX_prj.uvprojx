# Keil uVision project CubeMX_prj.uvprojx, settings and files
target CubeMX_prj (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CubeMX_prj +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;   ../Drivers/CMSIS/Include;   ..\LinkSDK;   ..\LinkSDK\atm;   ..\LinkSDK\dev_model;   ..\LinkSDK\dev_sign;   ..\LinkSDK\infra;   ..\LinkSDK\mqtt;   ..\LinkSDK\wrappers;   ..\LinkSDK\wrappers\external_libs;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c gpio.c dma.c freertos.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group atm
    ../LinkSDK/atm/: at_api.c at_conn_mbox.c at_conn_mgmt.c at_parser.c at_tcp.c
  group dev_model
    ../LinkSDK/dev_model/: dm_api.c dm_client.c dm_client_adapter.c dm_cota.c dm_fota.c dm_ipc.c dm_log_report.c dm_manager.c dm_message.c dm_message_cache.c dm_msg_process.c dm_opt.c dm_ota.c dm_server.c dm_server_adapter.c dm_shadow.c dm_tsl_alink.c dm_utils.c impl_gateway.c impl_linkkit.c impl_ntp.c impl_solo.c iotx_cm.c iotx_cm_coap.c iotx_cm_mqtt.c
  group dev_sign
    ../LinkSDK/dev_sign/: dev_sign_mqtt.c
  group infra
    ../LinkSDK/infra/: infra_cjson.c infra_compat.c infra_defs.c infra_log.c infra_net.c infra_prt_nwk_payload.c infra_report.c infra_sha256.c infra_string.c infra_timer.c
  group mqtt
    ../LinkSDK/mqtt/: iotx_mqtt_client.c mqtt_api.c MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group wrappers
    ../LinkSDK/wrappers/external_libs/: cJSON.c
    ../LinkSDK/wrappers/: wrapper.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0
